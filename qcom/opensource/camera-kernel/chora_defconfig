## qcom/opensource/camera-kernel/chora_defconfig
```kconfig
CONFIG_SPECTRA_ISP=y
CONFIG_SPECTRA_ICP=y
CONFIG_SPECTRA_SENSOR=y
CONFIG_SPECTRA_CRE=y
```
